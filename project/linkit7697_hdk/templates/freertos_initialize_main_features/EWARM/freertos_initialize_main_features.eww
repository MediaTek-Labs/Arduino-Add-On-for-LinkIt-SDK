<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\freertos_initialize_main_features.ewp</path>
  </project>
  <batchBuild/>
</workspace>


